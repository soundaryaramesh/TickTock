options:
  parameters:
    author: ltetest
    generate_options: no_gui
    id: sdrplay
    output_language: python
    title: RSP1A
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '1000000'
    step: '100000'
    stop: '100000000'
    value: '2000000'
  states: {state: disabled}
- name: center_freq
  id: variable
  parameters:
    value: 4.6e6
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '8192'
  states: {}
- name: filter_bandwidth
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: fun_prob
  id: variable_function_probe
  parameters:
    block_id: blocks_probe_signal_x_0
    function_name: level
    poll_rate: '5'
    value: 1e6
  states: {state: disabled}
- name: label
  id: variable_qtgui_label
  parameters:
    label: amp
    type: real
    value: center_freq
  states: {state: disabled}
- name: blocks_probe_signal_x_0
  id: blocks_probe_signal_x
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: bandwidth
    type: complex
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\nimport sys\nimport numpy as np\nfrom gnuradio import gr\nfrom configparser import ConfigParser\nimport json\nimport pmt\nimport datetime\nimport time\n\n# init parser\nparser = ConfigParser()\nparser.read(\"/home/pi/recording-mic-detection/python scripts/airspy/config.ini\")\nsdr = 'sdrplay'\n\npath_folders = json.loads(parser.get(sdr, 'rpi_syspath_addons'))\n\nfor folder in path_folders:\n    sys.path.append(folder)\n\nfrom utils import compute_all_center_frequencies as comp_cf\nfrom detect import detect_per_trial as dpt\n\nstart_cf = parser.getint(sdr, 'starting_center_freq')\n# max_harmonic = parser.getint(sdr, 'max_harmonic')\nrow_size = parser.getint(sdr, 'n_sweeps')\ncol_size = parser.getint(sdr, 'sampl_per_sweep')\nfreq_div = parser.getint(sdr, 'freq_per_sweep')\ncenter_freqs = comp_cf(start_cf, freq_div, row_size)\nprint(center_freqs)\n\n# # sweep specific\nbin_select = parser.get(sdr, 'bin_select')\nbin_skip = parser.getint(sdr, 'bin_skip')\n\n# peak detection param\nheight = parser.getfloat(sdr, 'height') #in dB\n\n# folder to save data\nsave_folder = parser.get(sdr, \"rpi_folder\")\n\n# init lists / matrices\nlogfft_mat = np.zeros([row_size,col_size], dtype=np.float32)\n\nlocal_ctr = 1\nfreq_ctr = 0\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, fft_size=8192, poll_rate=1, fname=\"tmp.bin\", compute=False):  # only default arguments here\n        self.fft_size = fft_size\n        self.poll_rate = poll_rate\n        self.fname = fname\n        self.compute = compute\n        self.fp = open(save_folder + self.fname, 'wb')\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='1-in-N-peak-detection',   # will show up in GRC\n            in_sig=[(np.float32, self.fft_size)],\n            # out_sig=[(np.float32, row_size*col_size)]\n            out_sig=None\n        )\n        self.message_port_register_out(pmt.intern('out_port'))\n\n\n    def work(self, input_items, output_items):\n        global freq_bitmap, logfft_mat\n        global freq_ctr, local_ctr\n\n        \"\"\" changing center freq \"\"\"\n        if local_ctr == self.poll_rate:\n            \"\"\" save previous center freq data \"\"\"\n            in0 = np.fft.fftshift(input_items[0][0])\n            if bin_select == \"both_sided\":\n                sidx = int(self.fft_size/2-col_size/2)\n                eidx = int(self.fft_size/2+col_size/2)\n            elif bin_select == \"right_sided\":\n                sidx = int(self.fft_size/2+bin_skip)\n                eidx = int(sidx+col_size)\n            else:\n                print(\"Error in bin select! Choose right_sided/both_sided\")\n            logfft_mat[freq_ctr][:] = in0[sidx:eidx]        \n\n\n            if freq_ctr == (row_size-1):\n                # print(\"All values satisfied!\")\n                logfft_list = logfft_mat.flatten()\n                # ly = logfft_list - np.mean(logfft_list)\n                # print(np.shape(ly))\n                # xf = (freq_offset + np.linspace(0, fs, N))/1e6\n                # plt.plot(xf,ly)\n                # plt.show()\n                np.save(self.fp, logfft_list)\n\n                logfft_mat = np.zeros([row_size,col_size], dtype=np.float32)\n                \n                if self.compute:\n                    start_t = time.time()\n                    _,_,_,_,clklist,_,_,_ = dpt(logfft_list, height, parser, sdr)\n                    end_t = time.time()\n                    #print(\"compute time: \",end_t-start_t)\n                    \n                    #for zz in range(int(3e5)):\n                    #    jj = zz + 1\n                    \n                    now = datetime.datetime.now()\n                    if clklist.size != 0:\n                        print(\"Time: \", now.hour,\":\",now.minute,\":\",\\\n                            now.second, \":\", round(now.microsecond/1e3), \\\n                            \", Clock frequency present at \", clklist, \"kHz!!\")\n                    else:\n                        print(\"Time: \", now.hour,\":\",now.minute,\":\",\\\n                            now.second, \":\", round(now.microsecond/1e3), \\\n                            \", Clock frequency NOT present\")\n\n            freq_ctr = (freq_ctr+1)%row_size\n            new_center_freq = center_freqs[freq_ctr]\n            #https://wiki.gnuradio.org/index.php/Soapy#Messages\n            # create pmt dict\n            msg_dict = pmt.make_dict()\n            key0 = pmt.intern(\"freq\") # center freq\n            val0 = pmt.from_double(float(new_center_freq))\n            msg_dict = pmt.dict_add(msg_dict, key0, val0)\n\n            self.message_port_pub(pmt.intern(\"out_port\"), msg_dict)\n            # print(\"Switching freq to \", new_center_freq/1e6,\" MHz\")\n\n            local_ctr = 1\n        else:\n            local_ctr += 1\n        return len(input_items[0])\n\n\n"
    compute: '0'
    fft_size: fft_size
    fname: '"l11_feas_15_mic_e.bin"'
    poll_rate: '1'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """
      # import sys
      # sys.path.append("~/gnuradio-folder")

      import numpy as np
      from gnuradio import gr
      # from epy_module_0 import get_f


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, fft_size=8192, center_freq=2e6):  # only default arguments here
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.fft_size = fft_size
              self.center_freq = center_freq

              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='FFT Shift',   # will show up in GRC
                  in_sig=[(np.float32, self.fft_size)],
                  out_sig=[(np.float32, self.fft_size)]
              )
              

          def work(self, input_items, output_items):
              # print("Center freq: ", self.center_freq)
              # print(epy_module_0.get_f())
              """example: multiply with constant"""
              in0 = input_items[0]
              out0_1 = np.fft.fftshift(in0)
              # shift the dB level such that the mean is 0
              # print(np.max(in0))
              avg_db_level = 0#np.average(in0)
              out0_2 = out0_1 - avg_db_level
              output_items[0][0]   = out0_2
              return len(output_items[0])
    center_freq: center_freq
    fft_size: fft_size
  states: {state: disabled}
- name: epy_module_0
  id: epy_module
  parameters:
    source_code: |-
      # # this module will be imported in the into your flowgraph
      from configparser import ConfigParser

      cname = 'grc-phase-1'
      # init parser
      parser = ConfigParser()
      parser.read("/home/ltetest/Desktop/recording-mic-detection/python scripts/airspy/config.ini")

      f1 = parser.getint(cname, 'starting_center_freq')
      freq_div = parser.getint(cname, 'freq_per_sweep')
      n_sweeps = parser.getint(cname, 'n_sweeps')

      idx = 1
      f = f1

      # # f1 = 0.33e6
      # # f2 = 20e6


      # # step = 0.66e6

      def sweeper(prob_lvl):
      	# print("Probe level: ", prob_lvl)
      	# global f1,f2,f,step
      	global f, idx
      	if prob_lvl:
      		f = f + freq_div
      		idx = idx + 1
      	if idx > n_sweeps: 
      		f = f1
      		idx = 1
      	return f
  states: {state: disabled}
- name: logpwrfft_x_0
  id: logpwrfft_x
  parameters:
    average: 'False'
    avg_alpha: '0.1'
    fft_size: fft_size
    frame_rate: '15'
    ref_scale: '2'
    sample_rate: bandwidth
    type: complex
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    vlen: fft_size
    x_start: center_freq - bandwidth/2
    x_step: bandwidth/fft_size
  states: {state: disabled}
- name: soapy_source_0
  id: soapy_source
  parameters:
    agc0: 'False'
    balance0: '0'
    bw0: filter_bandwidth
    center_freq0: center_freq
    correction0: '0'
    dc_offset0: '0'
    dc_removal0: 'True'
    devname: sdrplay
    overall_gain0: '10'
    samp_rate: bandwidth
    sdrplay_agc_setpoint: '-30'
    sdrplay_biastee: 'False'
    sdrplay_dabnotch: 'False'
    sdrplay_if_mode: Zero-IF
    sdrplay_rfnotch: 'False'
    type: fc32
  states: {}

connections:
- [blocks_throttle_0, '0', blocks_probe_signal_x_0, '0']
- [blocks_throttle_0, '0', logpwrfft_x_0, '0']
- [epy_block_0, out_port, soapy_source_0, command]
- [logpwrfft_x_0, '0', epy_block_0, '0']
- [soapy_source_0, '0', logpwrfft_x_0, '0']

metadata:
  file_format: 1
