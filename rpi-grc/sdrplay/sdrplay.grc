options:
  parameters:
    generate_options: qt_gui
    id: sdrplay
    output_language: python
    title: RSP1A
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 6.6e6
  states: {state: disabled}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 0e6
    step: 100e3
    stop: 100e6
    value: 5e6
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '8192'
  states: {}
- name: filter_bandwidth
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_sink_x_1
  id: blocks_vector_sink_x
  parameters:
    type: float
    vlen: '1024'
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      local_ctr = 1
      msg_ctr = 0

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, fft_size=1024, poll_rate=4):  # only default arguments here
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.fft_size = fft_size
              self.poll_rate = poll_rate
              self.msg_list = [pmt.from_double(15e6),pmt.from_double(6.6e6)]

              """arguments to this function show up as parameters in GRC"""

              gr.sync_block.__init__(
                  self,
                  name='Block for Sending Messages',   # will show up in GRC
                  in_sig=[(np.float32, self.fft_size)],
                  out_sig=[(np.float32, self.fft_size)]
              )
              self.message_port_register_out(pmt.intern('out_port'))

          def work(self, input_items, output_items):
              global msg_ctr, local_ctr

              output_items[0][:] = input_items[0]
              print("Center freq: ",self.msg_list[msg_ctr])

              if local_ctr == self.poll_rate:
                  #https://wiki.gnuradio.org/index.php/Soapy#Messages
                  # create pmt dict
                  msg_dict = pmt.make_dict()
                  key0 = pmt.intern("freq") # center freq
                  val0 = self.msg_list[msg_ctr]
                  msg_dict = pmt.dict_add(msg_dict, key0, val0)

                  # self.message_port_pub(pmt.intern('out_port'),
                  #                       self.msg_list[msg_ctr])
                  # self.message_port_pub(pmt.intern('out_port'), \
                  #     pmt.cons(pmt.intern("freq"),self.msg_list[msg_ctr])) 
                  self.message_port_pub(pmt.intern("out_port"), msg_dict)
                  msg_ctr += 1
                  local_ctr = 1
                  
                  if msg_ctr == len(self.msg_list):
                      msg_ctr = 0
              else:
                  local_ctr += 1
              return len(output_items[0])
    fft_size: fft_size
    poll_rate: '10'
  states: {state: disabled}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """
      import sys
      import numpy as np
      from gnuradio import gr
      from matplotlib import pyplot as plt
      from scipy.signal import find_peaks
      from configparser import ConfigParser
      import json

      # init parser
      parser = ConfigParser()
      parser.read("/home/ltetest/Desktop/recording-mic-detection/python scripts/airspy/config.ini")
      cname = 'max-peak-detection'

      start_cf = parser.getint(cname, 'starting_center_freq')
      row_size = parser.getint(cname, 'n_sweeps')
      col_size = parser.getint(cname, 'sampl_per_sweep')
      freq_div = parser.getint(cname, 'freq_per_sweep')
      expected_peak = parser.getfloat(cname, 'expected_peak')
      err_freq = parser.getfloat(cname, 'err_freq')
      max_ctr = parser.getint(cname, 'max_ct')
      peak_thresh = parser.getfloat(cname, 'peak_thresh')
      err_amp = parser.getfloat(cname, 'err_amp')

      fs = row_size * freq_div
      N = row_size * col_size

      ctr = 0
      score = 0

      # init lists / matrices
      freq_bitmap = np.zeros(row_size,dtype=bool)
      logfft_mat = np.zeros([row_size,col_size], dtype=np.float32)


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, fft_size=1024, center_freq=2e6):  # only default arguments here
              self.fft_size = fft_size
              self.center_freq = center_freq
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Max Peak Detection',   # will show up in GRC
                  in_sig=[(np.float32, self.fft_size)],
                  # out_sig=[(np.float32, row_size*col_size)]
                  out_sig=None
              )


          def work(self, input_items, output_items):
              global freq_bitmap, logfft_mat, ctr, score

              """example: multiply with constant"""
              in0 = input_items[0][0]
              k = int(np.around((self.center_freq-start_cf)/freq_div))
              # print("2: Center freq: ", self.center_freq)

              freq_bitmap[k] = True
              sidx = int(self.fft_size/2-col_size/2)
              eidx = int(self.fft_size/2+col_size/2)
              logfft_mat[k][:] = in0[sidx:eidx]

              if(np.all(freq_bitmap)):
                  ctr = ctr + 1

                  logfft_list = logfft_mat.flatten()
                  ly = logfft_list #- np.average(logfft_list)
                  xf = np.linspace(0, fs, N)/1000000.0
                  

                  freq_bitmap = np.zeros(row_size, dtype=bool)
                  logfft_mat = np.zeros([row_size,col_size], dtype=np.float32)

                  # peak_pos = np.argmax(ly)
                  peak_pos_bool = (np.amax(ly) - ly) < err_amp
                  peak_pos = np.where(peak_pos_bool)[0]
                  peak_val = ly[peak_pos_bool]
                  # print(np.shape(peaks))
                  fpeak = peak_pos * fs/float(N) / 1e6
                  print("Ctr: ", ctr, ", Peak Position: ", fpeak, "MHz, Peak Amplitude: ", peak_val, "dBm")
       
                  if len(fpeak) == 1:
                      if np.abs(fpeak - expected_peak) < err_freq:
                          score = score + 1
                          print("Score: ",score)
                      # plt.plot(xf, ly)
                      # plt.show()
                      # else:
                      #     plt.plot(xf, ly)
                      #     plt.show()

                  if ctr == max_ctr:
                      print("Accuracy: ",np.around(100 * score/max_ctr,2),"%")
                      ctr = 0
                      score = 0

              return len(input_items[0])
    center_freq: center_freq
    fft_size: fft_size
  states: {state: disabled}
- name: epy_block_0_1
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """
      import sys
      import numpy as np
      from gnuradio import gr
      from matplotlib import pyplot as plt
      from scipy.signal import find_peaks
      from configparser import ConfigParser
      import json

      # init parser
      parser = ConfigParser()
      parser.read("/home/ltetest/Desktop/recording-mic-detection/python scripts/airspy/config.ini")
      cname = 'grc-phase-1'

      path_folders = json.loads(parser.get(cname, 'syspath_addons'))

      for folder in path_folders:
          sys.path.append(folder)

      import clk_freq_detection as cfd 
      import peak_detection as pd

      start_cf = parser.getint(cname, 'starting_center_freq')
      row_size = parser.getint(cname, 'n_sweeps')
      col_size = parser.getint(cname, 'sampl_per_sweep')
      freq_div = parser.getint(cname, 'freq_per_sweep')
      max_harmonic = parser.getint(cname, 'max_harmonic')

      fs = row_size * freq_div
      N = row_size * col_size

      harmonics = np.arange(1,max_harmonic,2)
      n_harmonics = len(harmonics)

      # peak detection param
      height = parser.getfloat(cname, 'height') #in dB
      dist = parser.getfloat(cname, 'dist') #in samples
      # clk freq detection param
      score = parser.getint(cname, 'score')
      min_freq = parser.getint(cname, 'min_freq')
      max_freq = parser.getint(cname, 'max_freq')
      err_freq = parser.getfloat(cname, 'err_freq')

      # folder to save data
      save_folder = parser.get(cname, "folder")

      # init lists / matrices
      freq_bitmap = np.zeros(row_size,dtype=bool)
      logfft_mat = np.zeros([row_size,col_size], dtype=np.float32)


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, fft_size=1024, center_freq=2e6, fname="tmp.bin"):  # only default arguments here
              self.fft_size = fft_size
              self.center_freq = center_freq
              self.fname = fname
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='1-in-N-peak-detection',   # will show up in GRC
                  in_sig=[(np.float32, self.fft_size)],
                  # out_sig=[(np.float32, row_size*col_size)]
                  out_sig=None
              )


          def work(self, input_items, output_items):
              global freq_bitmap, logfft_mat
              
              # if(np.all(freq_bitmap)):
              #     logfft_mat = np.zeros([row_size,col_size], dtype=np.float32)

              """example: multiply with constant"""
              in0 = input_items[0][0]
              k = int(np.around((self.center_freq-start_cf)/freq_div))
              # print("2: Center freq: ", self.center_freq)

              freq_bitmap[k] = True
              sidx = int(self.fft_size/2-col_size/2)
              eidx = int(self.fft_size/2+col_size/2)
              logfft_mat[k][:] = in0[sidx:eidx]

              # output_items[0][0][:] = logfft_mat.flatten()
              if(np.all(freq_bitmap)):
                  # print("All values satisfied!")
                  
                  logfft_list = logfft_mat.flatten()
                  ly = logfft_list - np.average(logfft_list)
                  # print(np.shape(ly))
                  # xf = np.linspace(0, fs, N)/1000000.0
                  # plt.plot(xf,ly)
                  # plt.show()

                  with open(save_folder + self.fname, 'ab') as f:
                      np.save(f, logfft_list, allow_pickle=True)


                  freq_bitmap = np.zeros(row_size, dtype=bool)
                  logfft_mat = np.zeros([row_size,col_size], dtype=np.float32)
                  # else:
                  #     print(np.where(freq_bitmap))
                  # print(np.shape(output_items))

                  peaks, _ = pd.amplitude_based(ly, height, dist)
                  # print(np.shape(peaks))
                  fpeaks = peaks * fs/float(N)
                  # print("fpeaks: ", fpeaks)
                  pred_clk_freq_list, _ = cfd.detect_clk_freqs(fpeaks, \
                      score, harmonics, min_freq, max_freq, err_freq)

                  if pred_clk_freq_list.size != 0:
                      print("Clock frequency present at ", pred_clk_freq_list, "kHz!!")
                  else:
                      print("Clock frequency NOT present")

                  # _len = len(data)
                  # # assert _len <= self.output_size
                  # for x in range(_len):
                  #      output_items[0][x] = ord(data[x])
              return len(input_items[0])
    center_freq: center_freq
    fft_size: fft_size
    fname: '"dell_5459_ubuntu_recording.bin"'
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, fft_size=1024):  # only default arguments here
              self.fft_size = fft_size
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Block for Printing Messages',   # will show up in GRC
                  in_sig=[(np.float32, self.fft_size)],
                  out_sig=None
              )
              self.message_port_register_in(pmt.intern('in_port'))
              self.set_msg_handler(pmt.intern('in_port'),
                                   self.handle_msg)

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              # output_items[0][:] = input_items[0] * self.example_param
              return len(input_items[0])
          
          def handle_msg(self, msg):
              print(pmt.from_long(pmt.to_long(msg)))
    fft_size: '1024'
  states: {state: disabled}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """
      import sys
      import numpy as np
      from gnuradio import gr
      from matplotlib import pyplot as plt
      from scipy.signal import find_peaks
      from configparser import ConfigParser
      import json

      # init parser
      parser = ConfigParser()
      parser.read("/home/ltetest/Desktop/recording-mic-detection/python scripts/airspy/config.ini")
      cname = 'max-peak-detection'

      start_cf = parser.getint(cname, 'starting_center_freq')
      row_size = parser.getint(cname, 'n_sweeps')
      col_size = parser.getint(cname, 'sampl_per_sweep')
      freq_div = parser.getint(cname, 'freq_per_sweep')

      # fs = row_size * freq_div
      # N = row_size * col_size

      # init lists / matrices
      freq_bitmap = np.zeros(row_size,dtype=bool)
      ctr = 1

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, fft_size=1024, center_freq=2e6):  # only default arguments here
              self.fft_size = fft_size
              self.center_freq = center_freq
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='1-in-N-peak-detection',   # will show up in GRC
                  in_sig=[(np.float32, self.fft_size)],
                  # out_sig=[(np.float32, row_size*col_size)]
                  out_sig=None
              )


          def work(self, input_items, output_items):
              global freq_bitmap, ctr
              
              # if(np.all(freq_bitmap)):
              #     logfft_mat = np.zeros([row_size,col_size], dtype=np.float32)

              """example: multiply with constant"""
              in0 = input_items[0][0]
              k = int(np.around((self.center_freq-start_cf)/freq_div))
              print("ctr: ",ctr," k: ",k)
              ctr = ctr + 1
              # print("2: Center freq: ", self.center_freq)

              freq_bitmap[k] = True

              # output_items[0][0][:] = logfft_mat.flatten()
              if(np.all(freq_bitmap)):
                  freq_bitmap = np.zeros(row_size, dtype=bool)
                 
              return len(input_items[0])
    center_freq: center_freq
    fft_size: fft_size
  states: {state: disabled}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """
      import sys
      import numpy as np
      from gnuradio import gr
      from matplotlib import pyplot as plt
      from scipy.signal import find_peaks
      from configparser import ConfigParser
      import json
      import pmt
      import datetime

      # init parser
      parser = ConfigParser()
      parser.read("/home/pi/recording-mic-detection/python scripts/airspy/config.ini")

      sdr = 'sdrplay'
      peak_thresh = parser.getfloat(sdr, 'peak_thresh')

      center_freqs = [6.6e6,15e6] # always keep the one with peak at the end
      print("Center freqs: ", center_freqs)
      n_freq = len(center_freqs)

      local_ctr = 1
      msg_ctr = 0
      itr_ctr = 0
      score = 0
      total_itr = 100

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, fft_size=8192, poll_rate=4):  # only default arguments here
              self.fft_size = fft_size
              self.poll_rate = poll_rate
              
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Peak per range detection',   # will show up in GRC
                  in_sig=[(np.float32, self.fft_size)],
                  # out_sig=[(np.float32, row_size*col_size)]
                  out_sig=None
              )
              self.message_port_register_out(pmt.intern('out_port'))



          def work(self, input_items, output_items):
              global msg_ctr, local_ctr, itr_ctr, score

              center_freq = center_freqs[msg_ctr]

              """ peak detection """
              ly = input_items[0][0]
              peak_pos = np.argmax(ly)
              peak_val = ly[peak_pos]


              """ changing center freq """
              if local_ctr == self.poll_rate:
                  itr_ctr += 1
                  if peak_val > peak_thresh:
                      if msg_ctr == n_freq - 1: # the last center freq
                          score += 1
                      #print("Ctr: ", local_ctr, ", Center freq: ", center_freq/1e6,\
                      #    "MHz, Peak found!, Score: ",score,"/",itr_ctr)

                  else:
                      if msg_ctr != n_freq - 1: # not the last center freq
                          score += 1
                      #print("Ctr: ", local_ctr, ", Center freq: ", center_freq/1e6, \
                      #    "MHz, No peak!, Score: ",score,"/",itr_ctr)

                  if itr_ctr == total_itr:
                      now = datetime.datetime.now()
                      print("Time: ", now.hour,":",now.minute,":",\
                          now.second,", OVERALL SCORE: ",score,"/",itr_ctr)
                      itr_ctr = 0
                      score = 0

                  msg_ctr = (msg_ctr+1)%n_freq
                  new_center_freq = center_freqs[msg_ctr]
                  #https://wiki.gnuradio.org/index.php/Soapy#Messages
                  # create pmt dict
                  msg_dict = pmt.make_dict()
                  key0 = pmt.intern("freq") # center freq
                  val0 = pmt.from_double(new_center_freq)
                  msg_dict = pmt.dict_add(msg_dict, key0, val0)

                  self.message_port_pub(pmt.intern("out_port"), msg_dict)
                  # print("Switching freq to ", new_center_freq/1e6," MHz")

                  local_ctr = 1
              else:    
                  local_ctr += 1

              return len(input_items[0])
    fft_size: fft_size
    poll_rate: '1'
  states: {state: disabled}
- name: logpwrfft_x_0
  id: logpwrfft_x
  parameters:
    average: 'False'
    avg_alpha: '0.1'
    fft_size: fft_size
    frame_rate: '15'
    ref_scale: '2'
    sample_rate: samp_rate
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: fft_size
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    vlen: fft_size
    x_start: '0'
    x_step: '1.0'
  states: {}
- name: soapy_source_0
  id: soapy_source
  parameters:
    agc0: 'False'
    args: sdrplay
    balance0: '0'
    bw0: filter_bandwidth
    center_freq0: center_freq
    correction0: '0'
    dc_offset0: '0'
    dc_removal0: 'True'
    devname: sdrplay
    overall_gain0: '10'
    samp_rate: samp_rate
    sdrplay_agc_setpoint: '-30'
    sdrplay_biastee: 'False'
    sdrplay_dabnotch: 'False'
    sdrplay_if_mode: Zero-IF
    sdrplay_rfnotch: 'False'
    type: fc32
  states: {}

connections:
- [blocks_throttle_0, '0', blocks_null_sink_0, '0']
- [blocks_throttle_0, '0', logpwrfft_x_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [epy_block_0, '0', blocks_vector_sink_x_1, '0']
- [epy_block_0, '0', epy_block_1, '0']
- [epy_block_0, out_port, epy_block_1, in_port]
- [epy_block_3, out_port, soapy_source_0, command]
- [logpwrfft_x_0, '0', epy_block_3, '0']
- [logpwrfft_x_0, '0', qtgui_vector_sink_f_0, '0']
- [soapy_source_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
